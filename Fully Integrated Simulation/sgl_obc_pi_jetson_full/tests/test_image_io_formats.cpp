#include "../common/image_io.hpp"
#include "../common/reconstruction.hpp"

#include <filesystem>
#include <fstream>
#include <iostream>
#include <string>
#include <vector>

namespace fs = std::filesystem;

namespace {
const unsigned char kTinyPng[] = {
    0x89, 0x50, 0x4e, 0x47, 0x0d, 0x0a, 0x1a, 0x0a, 0x00, 0x00, 0x00, 0x0d, 0x49, 0x48, 0x44, 0x52, 0x00,
    0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x04, 0x03, 0x00, 0x00, 0x00, 0x80, 0x98, 0x10, 0x17, 0x00,
    0x00, 0x00, 0x20, 0x63, 0x48, 0x52, 0x4d, 0x00, 0x00, 0x7a, 0x26, 0x00, 0x00, 0x80, 0x84, 0x00, 0x00,
    0xfa, 0x00, 0x00, 0x00, 0x80, 0xe8, 0x00, 0x00, 0x75, 0x30, 0x00, 0x00, 0xea, 0x60, 0x00, 0x00, 0x3a,
    0x98, 0x00, 0x00, 0x17, 0x70, 0x9c, 0xba, 0x51, 0x3c, 0x00, 0x00, 0x00, 0x0f, 0x50, 0x4c, 0x54, 0x45,
    0xff, 0x00, 0x00, 0x00, 0xff, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0x00, 0xff, 0xff, 0xff, 0xf5, 0x4e,
    0x9d, 0xcf, 0x00, 0x00, 0x00, 0x01, 0x62, 0x4b, 0x47, 0x44, 0x04, 0x8f, 0x68, 0xd9, 0x51, 0x00, 0x00,
    0x00, 0x07, 0x74, 0x49, 0x4d, 0x45, 0x07, 0xea, 0x05, 0x06, 0x08, 0x2a, 0x2f, 0x5c, 0x29, 0xe2, 0x21,
    0x00, 0x00, 0x00, 0x0c, 0x49, 0x44, 0x41, 0x54, 0x08, 0xd7, 0x63, 0x60, 0x64, 0x50, 0x06, 0x00, 0x00,
    0x2a, 0x00, 0x25, 0xd3, 0x94, 0xe0, 0x84, 0x00, 0x00, 0x00, 0x00, 0x49, 0x45, 0x4e, 0x44, 0xae, 0x42,
    0x60, 0x82};

const unsigned char kTinyJpg[] = {
    0xff, 0xd8, 0xff, 0xe0, 0x00, 0x10, 0x4a, 0x46, 0x49, 0x46, 0x00, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0xff, 0xdb, 0x00, 0x43, 0x00, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x02, 0x02,
    0x02, 0x03, 0x03, 0x03, 0x03, 0x04, 0x06, 0x04, 0x04, 0x04, 0x04, 0x04, 0x08, 0x06, 0x06, 0x05, 0x06,
    0x09, 0x08, 0x0a, 0x0a, 0x09, 0x08, 0x09, 0x09, 0x0a, 0x0c, 0x0f, 0x0c, 0x0a, 0x0b, 0x0e, 0x0b, 0x09,
    0x09, 0x0d, 0x11, 0x0d, 0x0e, 0x0f, 0x10, 0x10, 0x11, 0x10, 0x0a, 0x0c, 0x12, 0x13, 0x12, 0x10, 0x13,
    0x0f, 0x10, 0x10, 0x10, 0xff, 0xdb, 0x00, 0x43, 0x01, 0x03, 0x03, 0x03, 0x04, 0x03, 0x04, 0x08, 0x04,
    0x04, 0x08, 0x10, 0x0b, 0x09, 0x0b, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
    0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
    0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
    0x10, 0x10, 0x10, 0x10, 0x10, 0xff, 0xc0, 0x00, 0x11, 0x08, 0x00, 0x02, 0x00, 0x02, 0x03, 0x01, 0x11,
    0x00, 0x02, 0x11, 0x01, 0x03, 0x11, 0x01, 0xff, 0xc4, 0x00, 0x14, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xff, 0xc4, 0x00, 0x1d, 0x10,
    0x00, 0x02, 0x02, 0x03, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
    0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x00, 0x11, 0x21, 0xff, 0xc4, 0x00, 0x15, 0x01, 0x01, 0x01, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0xff, 0xc4,
    0x00, 0x1d, 0x11, 0x01, 0x01, 0x00, 0x02, 0x02, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x02, 0x01, 0x03, 0x04, 0x05, 0x11, 0x00, 0x06, 0x07, 0x22, 0xff, 0xda, 0x00, 0x0c, 0x03,
    0x01, 0x00, 0x02, 0x11, 0x03, 0x11, 0x00, 0x3f, 0x00, 0x57, 0xf0, 0x1d, 0x57, 0x57, 0xbf, 0xc2, 0x39,
    0xc5, 0xeb, 0xda, 0xde, 0x2e, 0xc5, 0x9b, 0x1a, 0x96, 0x1e, 0x59, 0xa6, 0x96, 0x9c, 0x6e, 0xf2, 0x3b,
    0x53, 0x88, 0xb3, 0x33, 0x11, 0xec, 0x92, 0x49, 0x24, 0x9f, 0xa4, 0x9f, 0x20, 0x4f, 0xb5, 0x6c, 0x66,
    0xe3, 0xbe, 0x97, 0xec, 0x5a, 0x7a, 0x6e, 0xe3, 0xc5, 0x8f, 0x7b, 0x6c, 0x80, 0x6d, 0x24, 0x93, 0xb1,
    0x92, 0x12, 0x4c, 0xea, 0x12, 0x64, 0x92, 0x49, 0x24, 0x92, 0x75, 0x3c, 0x58, 0xf5, 0x4e, 0x03, 0x96,
    0x33, 0x90, 0xe4, 0x34, 0x70, 0xe5, 0xcf, 0x97, 0xf6, 0xdb, 0xc4, 0x13, 0x6d, 0x7e, 0x93, 0x69, 0x1a,
    0x92, 0x4a, 0xda, 0x95, 0xb6, 0xdb, 0x6d, 0xb7, 0xbf, 0x3f, 0xff, 0xd9};
}

static bool write_blob(const fs::path& p, const unsigned char* bytes, size_t n) {
  std::ofstream f(p, std::ios::binary);
  if (!f) return false;
  f.write(reinterpret_cast<const char*>(bytes), static_cast<std::streamsize>(n));
  return !!f;
}

int main() {
  const fs::path root = fs::current_path() / "tmp_test_image_io_formats";
  std::error_code ec;
  fs::remove_all(root, ec);
  fs::create_directories(root, ec);
  if (ec) {
    std::cerr << "mkdir failed: " << ec.message() << "\n";
    return 1;
  }

  sgl::ImageRGBA ppm{};
  ppm.w = 2;
  ppm.h = 2;
  ppm.rgba = {
      255, 0, 0, 255, 0, 255, 0, 255,
      0, 0, 255, 255, 255, 255, 0, 255,
  };
  const fs::path ppm_path = root / "tiny.ppm";
  if (!sgl::write_ppm(ppm_path.string(), ppm)) {
    std::cerr << "write ppm failed\n";
    return 1;
  }
  const fs::path png_path = root / "tiny.png";
  const fs::path jpg_path = root / "tiny.jpg";
  if (!write_blob(png_path, kTinyPng, sizeof(kTinyPng))) return 1;
  if (!write_blob(jpg_path, kTinyJpg, sizeof(kTinyJpg))) return 1;

  for (const auto& p : {ppm_path, png_path, jpg_path}) {
    sgl::ImageRGBA img{};
    std::string err;
    if (!sgl::read_image_auto(p.string(), img, err)) {
      std::cerr << "read_image_auto failed: " << p << " err=" << err << "\n";
      return 1;
    }
    if (img.w != 2 || img.h != 2 || img.rgba.size() != 16) {
      std::cerr << "unexpected size for " << p << ": " << img.w << "x" << img.h << " bytes=" << img.rgba.size() << "\n";
      return 1;
    }
  }

  sgl::SourcePreconditioningConfig cfg{};
  cfg.canvas_N = 256;
  cfg.object_type = "disk_planet";
  sgl::SourcePreconditioningResult out{};
  std::string err;
  for (const auto& p : {ppm_path, png_path, jpg_path}) {
    if (!sgl::precondition_source_image(p.string(), root.string(), cfg, out, err)) {
      std::cerr << "precondition_source_image failed: " << p << " err=" << err << "\n";
      return 1;
    }
    if (out.preconditioned_source_path.empty() || !fs::exists(out.preconditioned_source_path)) {
      std::cerr << "missing preconditioned output for " << p << "\n";
      return 1;
    }
  }
  return 0;
}
